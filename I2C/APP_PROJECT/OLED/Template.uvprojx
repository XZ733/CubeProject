# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: .\Libraries\CMSIS;.\Libraries\STM32F1xx_HAL_Driver\Inc;.\User;.\Public;.\APP\led;.\APP\key;.\APP\pwm;.\APP\exti;.\APP\motor;.\APP\i2c;.\APP\24c02;.\APP\oled
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: main.c stm32f1xx_it.c system_stm32f1xx.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f103xe.s
  group HAL_Driver
    ./Libraries/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_usart.c stm32f1xx_hal_uart.c
  group CMSIS
    ./Libraries/CMSIS/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h core_cm3.h
  group APP
    ./APP/led/: led.c
    ./APP/pwm/: pwm.c
    ./APP/motor/: motor.c
    ./APP/i2c/: i2c.c
    ./APP/key/: key.c
    ./APP/exti/: exti.c
    ./APP/24c02/: 24c02.c
    ./APP/oled/: oled.c
  group Public
    ./Public/: system.c Systick.c usart.c
